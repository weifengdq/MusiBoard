# Keil uVision project receive.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: receive +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./SRC/: adc.c ascii.c delay.c gb1616.c gb3232.c hmc5883l.c image0.c interrupt.c lcd.c lkb.c main.c mpu6050.c nrf24l01.c pca_pwm.c timer.c uart.c
