# Keil uVision project TheEnd.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TheEnd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./SRC/: adc.c delay.c image0.c interrupt.c lcd.c lkb.c main.c mpu6050.c timer.c uart.c gb1616.c ascii.c gb3232.c pca_pwm.c hmc5883l.c nrf24l01.c int.c
